Commit message: commit

File: install/arms_description/share/arms_description/urdf/T170_ARMS.urdf (robot description, URDF)
Before this commit: robot T170_ARMS, 18 links, 17 joints
Joints:
- joint L_SHOULDER_Y: axis 0 -1 0 -> 0 1 0
